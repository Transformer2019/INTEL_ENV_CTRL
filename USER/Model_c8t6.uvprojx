# Keil uVision project Model_c8t6.uvprojx, settings and files
target Model (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: GD32F103CB GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.3
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Model_c8t6 +hex
  AfterMake: fromelf --bin --output ../OBJ/@L.bin ../OBJ/@L.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\USER;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\KEY;..\HARDWARE\TIMER;..\FWLib\inc;..\CORE;..\HARDWARE\RTC;..\HARDWARE\GLOBAL;..\HARDWARE\74HC595;..\HARDWARE\NTC;..\HARDWARE\FLASH;..\HARDWARE\LCD;..\HARDWARE\GP8201S;..\HARDWARE\MMODBUS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ../FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HARDWARE
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/74HC595/: 74HC595.c
    ../HARDWARE/NTC/: ntc.c
    ../HARDWARE/GLOBAL/: global.h global.c
    ../HARDWARE/FLASH/: flash.c
    ../HARDWARE/LCD/: FONT.H gui.c gui.h lcd.c lcd.h oledfont.h SPI.c SPI.h UI.c UI.h
    ../HARDWARE/GP8201S/: GP8201S.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart1.c
  group MODBUS
    ../HARDWARE/MMODBUS/: mb_crc.c mb_crc.h mb_hook.c mb_hook.h mb_host.c mb_host.h mb_include.h mb_port.c mb_port.h
software components: Data Exchange:JSON:Jansson 2.7.0
